# IAR project 743.ewp, settings and files
configuration 743 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743VI ST STM32H743VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ../Inc; ../Inc/modules; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STemWin/inc; ../Middlewares/ST/STemWin/App; ../Middlewares/ST/STemWin/Config; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: 743.hex
  ILINK.IlinkOutputFile: 743.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c
  group Application/User/Fat_FS
    ../Src/: fatfs.c fatfs_platform.c sd_thread.c
  group Application/User/lcd
    ../Src/: ILI9806.c rm68120.c
  group Application/User/Utilities/font
    ../Src/fonts/: Segment762.c Verdana16.c verdana220.c Verdana23.c Verdana32.c Verdana36.c Verdana42.c Verdana45.c Verdana45_rus.c Verdana62.c verdana96.c
  group Application/User/Utilities/Icons
    ../Src/icons/: beh.c bffh.c bfh.c blh.c bmh.c bmmh.c mute.c mute_empty.c
  group Application/User/Utilities/Modules
    ../Src/: calendar.c
  group Drivers/Board
    ../Src/: bmp280.c board.c bsp_driver_sd.c lcd_pwm.c sd_diskio.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c w25qxx.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/I2C_soft
    ../Src/: i2c_routines.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Drivers/USB
    ../Src/: usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
  group Drivers/USB/library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/EmWIN/Config
    ../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Middlewares/ST/STemWin/Config/: GUIConf.c LCD_ILI9806_conf.c
  group Middlewares/EmWIN/LIB
    ../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_IAR.a
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
